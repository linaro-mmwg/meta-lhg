# WPE 2017 require these gst plugins
PACKAGECONFIG_append_imx = " opusparse faad"
