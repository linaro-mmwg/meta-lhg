# WPE 2017 requires opus
PACKAGECONFIG_append_imx = " opus"
