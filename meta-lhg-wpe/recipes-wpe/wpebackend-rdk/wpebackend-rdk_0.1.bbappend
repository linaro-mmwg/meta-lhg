CXXFLAGS_append_mx8 = " -DLINUX -DEGL_API_FB -DWL_EGL_PLATFORM"

