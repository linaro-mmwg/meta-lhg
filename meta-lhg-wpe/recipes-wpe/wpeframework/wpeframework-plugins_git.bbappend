# Enable CDMi
PACKAGECONFIG_append = " opencdmi opencdmi_pr"
