FILESEXTRAPATHS_prepend := "${THISDIR}/../westeros/files:"

SRC_URI_append = " file://unable-to-get-an-encoder-for-connector-fix.patch"
