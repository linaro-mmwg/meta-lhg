
CXXFLAGS_append_mx8 = " -DLINUX -DEGL_API_FB -DWL_EGL_PLATFORM"
CFLAGS_append_mx8 = " -DLINUX -DEGL_API_FB -DWL_EGL_PLATFORM"
PACKAGECONFIG_remove_imx = " x11"

