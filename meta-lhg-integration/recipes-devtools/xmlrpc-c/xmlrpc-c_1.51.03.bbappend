FILESEXTRAPATHS_append := "${THISDIR}/${PN}"

SRC_URI += "file://0001-Remove-stderr-messages.patch \
           "
